Commit message: urdf

File: src/sam_bot_odom_py/urdf/sam_bot.urdf (robot description, URDF)
Before this commit: robot mycar, 8 links, 7 joints
Joints:
- joint lidar_joint: origin xyz=0.0 0.0 0.045 rpy=0.0 0.0 0.0 -> xyz=0.0 0.0 0.045 rpy=3.1415926535 0.0 0.0
